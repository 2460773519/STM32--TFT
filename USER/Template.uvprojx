# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\SYSTEM\LED;..\SYSTEM\lcd_1602;..\SYSTEM\mn_spi;..\SYSTEM\TIMER;..\SYSTEM\SPI;..\SYSTEM\KEY;..\SYSTEM\TFT;..\SYSTEM\my
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/lcd_1602/: LCD1602.c
    ../SYSTEM/LED/: led.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/mn_spi/: mn_spi.c
    ../SYSTEM/SPI/: spi.c
    ../SYSTEM/KEY/: key.c
    ../SYSTEM/TFT/: SEEKFREE_18TFT.c SEEKFREE_FONT.c SEEKFREE_PRINTF.c
    ../SYSTEM/my/: my.c
  group README
    ../: readme.txt
